# IAR project BlinkySDK.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CPU_MIMXRT1062DVL6A; DISABLE_WDOG
  ICCARM.CCIncludePath2: C:\Users\Baueflde\Desktop\NXP_BlinkySDK\drivers\CMSIS_inc; C:\Users\Baueflde\Desktop\NXP_BlinkySDK\drivers; C:\Users\Baueflde\Desktop\NXP_BlinkySDK\StartUp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group boardFiles
    drivers/: fsl_clock.c fsl_common.c fsl_common_arm.c fsl_gpio.c system_MIMXRT1062.c
